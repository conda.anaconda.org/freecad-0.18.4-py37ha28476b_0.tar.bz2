** written by FreeCAD inp file writer for CalculiX,Abaqus meshes
** highest dimension mesh elements only.

** Nodes
*Node, NSET=Nall
1, 6, 12, 18
2, 0, 0, 18
3, 12, 0, 18
4, 6, 6, 0
5, 3, 6, 18
6, 6, 0, 18
7, 9, 6, 18
8, 6, 9, 9
9, 3, 3, 9
10, 9, 3, 9


** Volume elements
*Element, TYPE=C3D10, ELSET=Evolumes
1, 2, 1, 3, 4, 5, 7, 6, 9, 8, 10

** Define element set Eall
*ELSET, ELSET=Eall
Evolumes
