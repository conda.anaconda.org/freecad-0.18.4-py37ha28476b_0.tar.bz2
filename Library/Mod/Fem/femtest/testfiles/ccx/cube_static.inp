** written by FreeCAD inp file writer for CalculiX,Abaqus meshes
** highest dimension mesh elements only.

** Nodes
*Node, NSET=Nall
1, 0, 0, 0
2, 0, 0, 10
3, 0, 10, 0
4, 0, 10, 10
5, 10, 0, 0
6, 10, 0, 10
7, 10, 10, 0
8, 10, 10, 10
9, 0, 0, 5
10, 0, 0, 2.5
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

** Volume elements
*Element, TYPE=C3D10, ELSET=Evolumes
1, 95, 98, 47, 196, 103, 197, 198, 200, 199, 201
2, 147, 121, 145, 196, 203, 202, 161, 205, 204, 206
3, 73, 70, 27, 121, 84, 80, 83, 208, 207, 136
4, 72, 170, 30, 171, 209, 187, 75, 210, 181, 194
5, 9, 98, 47, 95, 101, 197, 54, 102, 103, 198
6, 172, 70, 30, 71, 211, 78, 186, 212, 93, 91
7, 170, 99, 36, 174, 213, 119, 184, 191, 214, 190
8, 12, 47, 149, 145, 57, 215, 150, 152, 216, 155
9, 70, 27, 123, 72, 80, 143, 217, 79, 77, 218
10, 39, 147, 121, 145, 160, 203, 132, 159, 161, 202
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
** Define element set Eall
*ELSET, ELSET=Eall
Evolumes


***********************************************************
** Element sets for materials and FEM element type (solid, shell, beam, fluid)
** written by write_element_sets_material_and_femelement_type function
*ELSET,ELSET=MechanicalMaterialSolid
Evolumes

***********************************************************
** Node sets for fixed constraint
** written by write_node_sets_constraints_fixed function
** FemConstraintFixed
*NSET,NSET=FemConstraintFixed
1,
2,
3,
4,
9,
10,
11,
12,
13,
14,
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
***********************************************************
** Materials
** written by write_materials function
** Young's modulus unit is MPa = N/mm2
** FreeCAD material name: Steel-Generic
** MechanicalMaterial
*MATERIAL, NAME=MechanicalMaterial
*ELASTIC
200000, 0.300

***********************************************************
** Sections
** written by write_femelementsets function
*SOLID SECTION, ELSET=MechanicalMaterialSolid, MATERIAL=MechanicalMaterial

***********************************************************
** At least one step is needed to run an CalculiX analysis of FreeCAD
** written by write_step_begin function
*STEP
*STATIC


***********************************************************
** Fixed Constraints
** written by write_constraints_fixed function
** FemConstraintFixed
*BOUNDARY
FemConstraintFixed,1
FemConstraintFixed,2
FemConstraintFixed,3


***********************************************************
** Node loads Constraints
** written by write_constraints_force function
*CLOAD
** FemConstraintForce
** node loads on shape: Box:Face6
2,3,-0.0000000000000E+00
4,3,-0.0000000000000E+00
6,3,-0.0000000000000E+00
8,3,-0.0000000000000E+00
18,3,-0.0000000000000E+00
19,3,-8.3333333333333E+02
20,3,-8.3333333333333E+02
30,3,-0.0000000000000E+00
31,3,-8.3333333333333E+02
32,3,-8.3333333333333E+02
36,3,-0.0000000000000E+00
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

***********************************************************
** Element + CalculiX face + load in [MPa]
** written by write_constraints_pressure function
** FemConstraintPressure
*DLOAD
** FemConstraintPressure: face load
3,P1,1000.0
6,P3,1000.0
9,P2,1000.0
36,P1,1000.0
38,P1,1000.0
56,P1,1000.0
61,P3,1000.0
67,P2,1000.0
68,P3,1000.0
75,P2,1000.0
76,P4,1000.0
78,P4,1000.0
79,P2,1000.0
90,P3,1000.0
105,P3,1000.0
125,P3,1000.0

***********************************************************
** Outputs --> frd file
** written by write_outputs_types function
*NODE FILE
U
*EL FILE
S, E

***********************************************************
** written by write_step_end function
*END STEP

***********************************************************
** CalculiX Input file
** written by write_footer function
**   written by    --> FreeCAD 0.17.9749 (Git)
**   written on    --> Sun Jan 22 14:28:56 2017
**   file name     -->
**   analysis name --> Analysis
**
**
**
**   Units
**
**   Geometry (mesh data)        --> mm
**   Materials (Young's modulus) --> N/mm2 = MPa
**   Loads (nodal loads)         --> N
**
